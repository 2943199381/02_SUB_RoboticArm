Commit message: 基本完成

File: urdf/02_SUB_RoboticArm_payload.urdf (robot description, URDF)
Before this commit: robot 02_SUB_RoboticArm, 7 links, 6 joints
Links:
- link payload_center_link: mass 0.0 -> 0.63; geometry collision box size=0.35 0.35 0.35; visual box size=0.35 0.35 0.35
